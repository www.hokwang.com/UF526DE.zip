Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: UF526.IFC
Time: 2022-01-06T05:33:24
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 102-02
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 102-04_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-05_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-201_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-202_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-39
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 102-40
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 102-43
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-73
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 102-76
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-77N
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 102-88_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 102-89_AF0
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 126-01-1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 126-02_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0
